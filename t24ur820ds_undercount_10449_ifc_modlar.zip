Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 10.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ArchiCAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [IFC base quantities (size, area and volume): Off], Option [All ArchiCAD BIM parameters: Off], Option [IFC Space boundaries: Off], Option [ArchiCAD Zone Categories as IFC Space classification data: Off]
File name: /Users/FernMacBookpro/Google Drive/Modlar Working Projects/Thermador - 032016/Backup/Models/T24UR820DS UNDER-COUNTER DOUBLE DRAWER REFRIGERATOR.ifc
Time: 2016-04-22T12:12:22
Author: Architect
Organization: Building Designer Office
Written by: PreProc - EDM 5.0
Made in: IFC file generated by Graphisoft ArchiCAD-64 18.0.0 NZE FULL Macintosh version (IFC2x3 add-on version: 3006 NZE FULL).
Authorization: The authorising person

# IfcSite, Site
RefLatitude: -36, -50, 0, 0; RefLongitude: 174, 46, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Ground Floor
In: Building
Elevation: 0 mm

# IfcFurnishingElement: T24UR820DS UNDER-COUNTER DOUBLE DRAWER REFRIGERATOR, OB - 0030
In: Ground Floor
Material: Background Fill
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
